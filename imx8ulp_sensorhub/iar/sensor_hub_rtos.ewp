# IAR project sensor_hub_rtos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8UD5_M33 NXP MIMX8UD5_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX8UD7DVP10_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_PCA6416A=1; BOARD_USE_TPM=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../srtm/channels; ../srtm/services; ../../../../../components/codec/i2c; ../../../../../devices/MIMX8UD7/drivers; ../../../../../components/i2c; ../../../../../components/codec; ../../../../../components/codec/port/wm8960; ../../../../../components/codec/port; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos; ../../../../../devices/MIMX8UD7; ../../../../../devices/MIMX8UD7/utilities/str; ../../../../../devices/MIMX8UD7/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMX8UD7/drivers/upower; ../../../../../CMSIS/Core/Include; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../components/pca6416a; ../../../../../components/lsm6dso; ../../../../../components/srtm/include; ../../../../../components/srtm/srtm; ../../../../../components/srtm/port; ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8ulp_m33; ../../../../../components/pwm; ../../../../../components/rtc; ../../../../../components/codec/wm8960; ../paint
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: m33_image.bin
  ILINK.IlinkOutputFile: sensor_hub_rtos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x10000
  ILINK.IlinkIcfFile: MIMX8UD7xxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMX8UD7_M33 NXP MIMX8UD7_M33
  General.CoreVariant: 58
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MIMX8UD7DVP10_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_PCA6416A=1; BOARD_USE_TPM=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: ..; ../../..; ../srtm/channels; ../srtm/services; ../../../../../components/codec/i2c; ../../../../../devices/MIMX8UD7/drivers; ../../../../../components/i2c; ../../../../../components/codec; ../../../../../components/codec/port/wm8960; ../../../../../components/codec/port; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos; ../../../../../devices/MIMX8UD7; ../../../../../devices/MIMX8UD7/utilities/str; ../../../../../devices/MIMX8UD7/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMX8UD7/drivers/upower; ../../../../../CMSIS/Core/Include; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../components/pca6416a; ../../../../../components/lsm6dso; ../../../../../components/srtm/include; ../../../../../components/srtm/srtm; ../../../../../components/srtm/port; ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8ulp_m33; ../../../../../components/pwm; ../../../../../components/rtc; ../../../../../components/codec/wm8960
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400
  ILINK.IlinkIcfFile: MIMX8UD7xxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMX8UD7_M33 NXP MIMX8UD7_M33
  General.CoreVariant: 58
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8UD7DVP10_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_PCA6416A=1; BOARD_USE_TPM=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400
configuration flash_release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMX8UD7_M33 NXP MIMX8UD7_M33
  General.CoreVariant: 58
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MIMX8UD7DVP10_cm33; NDEBUG; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_PCA6416A=1; BOARD_USE_TPM=1; SDK_I2C_BASED_COMPONENT_USED=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400
  ILINK.IlinkIcfFile: MIMX8UD7xxxxx_cm33_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group codec
    ../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../../../../../components/codec/i2c/: fsl_codec_i2c.c fsl_codec_i2c.h
    ../../../../../components/codec/wm8960/: fsl_wm8960.c fsl_wm8960.h
  group codec/port
    ../../../../../components/codec/port/: fsl_codec_adapter.h
  group codec/port/wm8960
    ../../../../../components/codec/port/wm8960/: fsl_codec_wm8960_adapter.c fsl_codec_wm8960_adapter.h
  group component/i2c
    ../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/pwm
    ../../../../../components/pwm/: fsl_adapter_pwm.h fsl_adapter_pwm_tpm.c
  group component/rtc
    ../../../../../components/rtc/: fsl_adapter_rtc.h fsl_adapter_rtc_bbnsm.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group components/pca6416a
    ../../../../../components/pca6416a/: fsl_pca6416a.c fsl_pca6416a.h
  group device
    ../../../../../devices/MIMX8UD7/: fsl_device_registers.h MIMX8UD7_cm33.h MIMX8UD7_cm33_features.h system_MIMX8UD7_cm33.c system_MIMX8UD7_cm33.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMX8UD7/drivers/: fsl_bbnsm.c fsl_bbnsm.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_edma.c fsl_edma.h fsl_flexspi.c fsl_flexspi.h fsl_fusion.c fsl_fusion.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_mu.c fsl_mu.h fsl_reset.c fsl_reset.h fsl_rgpio.c fsl_rgpio.h fsl_rtd_cmc.c fsl_rtd_cmc.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sentinel.c fsl_sentinel.h fsl_tpm.c fsl_tpm.h fsl_trdc.c fsl_trdc.h fsl_upower.c fsl_upower.h fsl_wuu.c fsl_wuu.h
  group drivers/freertos
    ../../../../../devices/MIMX8UD7/drivers/: fsl_lpi2c_freertos.c fsl_lpi2c_freertos.h
  group drivers/upower
    ../../../../../devices/MIMX8UD7/drivers/upower/: upmu.h upower_api.c upower_api.h upower_defs.h upower_soc_defs.h
  group evkmimx8ulp
    ../: app_srtm.c app_srtm.h
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group paint
    ../paint/: debug_paint.h font12.c font12CN.c font16.c font20.c font24.c font24CN.c font8.c fonts.h gui_paint.c gui_paint.h
  group remoteproc
    ../: empty_rsc_table.c remoteproc.h rsc_table.c rsc_table.h
  group rpmsg_lite/common
    ../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
  group rpmsg_lite/include
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/: llist.h rpmsg_compiler.h rpmsg_default_config.h rpmsg_env.h rpmsg_lite.h rpmsg_ns.h rpmsg_queue.h virtio_ring.h virtqueue.h
  group rpmsg_lite/include/environment/freertos
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/environment/freertos/: rpmsg_env_specific.h
  group rpmsg_lite/porting
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx8ulp_m33/: rpmsg_platform.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8ulp_m33/: rpmsg_platform.h
  group rpmsg_lite/rpmsg_lite
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c
  group rpmsg_lite/rpmsg_lite/porting/environment
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg_lite/virtio
    ../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group source
    ../: FreeRTOSConfig.h gpio_app.c gpio_app.h lpm.c lpm.h lpspi_app.c lpspi_app.h pwm_app.c pwm_app.h rpmsg_config.h sensor_app.c sensor_app.h sensor_hub_rtos.c sensor_hub_rtos.h srtm_config.h
  group srtm/channels
    ../srtm/channels/: srtm_rpmsg_endpoint.c srtm_rpmsg_endpoint.h
  group srtm/include
    ../../../../../components/srtm/include/: srtm_channel.h srtm_defs.h srtm_dispatcher.h srtm_message.h srtm_peercore.h srtm_service.h
  group srtm/port
    ../../../../../components/srtm/port/: srtm_heap_freertos.c srtm_message_pool.c srtm_mutex_freertos.c srtm_sem_freertos.c
  group srtm/services
    ../srtm/services/: srtm_audio_service.c srtm_audio_service.h srtm_i2c_service.c srtm_i2c_service.h srtm_io_service.c srtm_io_service.h srtm_keypad_service.c srtm_keypad_service.h srtm_lfcl_service.c srtm_lfcl_service.h srtm_pwm_adapter.c srtm_pwm_adapter.h srtm_pwm_service.c srtm_pwm_service.h srtm_rtc_adapter.c srtm_rtc_adapter.h srtm_rtc_service.c srtm_rtc_service.h srtm_sai_edma_adapter.c srtm_sai_edma_adapter.h srtm_sensor_service.c srtm_sensor_service.h
  group srtm/srtm
    ../../../../../components/srtm/srtm/: srtm_channel.c srtm_channel_struct.h srtm_dispatcher.c srtm_dispatcher_struct.h srtm_heap.h srtm_list.h srtm_message.c srtm_message_pool.h srtm_message_struct.h srtm_mutex.h srtm_peercore.c srtm_peercore_struct.h srtm_sem.h srtm_service.c srtm_service_struct.h
  group startup
    ../../../../../devices/MIMX8UD7/iar/: startup_MIMX8UD7_cm33.s
  group tilt_pedo
    ../../../../../components/lsm6dso/: fsl_lsm.c fsl_lsm.h
  group utilities
    ../../../../../devices/MIMX8UD7/utilities/: fsl_assert.c
    ../../../../../devices/MIMX8UD7/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMX8UD7/utilities/str/: fsl_str.c fsl_str.h
